# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Core;.\App;.\BSP;.\Control;.\Drivers\Bus;.\Drivers\Communication;.\Drivers\Sensors;..\Platform\STM32F1\CMSIS;..\Platform\STM32F1\SPL;..\Platform\STM32F1\System;..\Shared\Protocol;..\Shared\Drivers;..\Shared\Scheduling
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xF800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Platform / CMSIS
    ../Platform/STM32F1/CMSIS/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Platform / SPL
    ../Platform/STM32F1/SPL/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Platform / System
    ../Platform/STM32F1/System/: Delay.c Delay.h flash_config.c flash_config.h
  group BSP
    BSP/: watchdog.c watchdog.h board_led.c board_led.h motor_pwm.c motor_pwm.h control_timers.c control_timers.h board_config.h
  group Drivers / Bus
    Drivers/Bus/: soft_i2c.c soft_i2c.h
  group Drivers / Sensors
    Drivers/Sensors/: mpu6050.c mpu6050.h mpu6050_regs.h
  group Control
    Control/: pid_controller.c pid_controller.h kalman_filter.c kalman_filter.h attitude_estimator.c attitude_estimator.h navigation_estimator.c navigation_estimator.h
  group Drivers / Communication
    Drivers/Communication/: crsf.c crsf.h bluetooth_serial.c bluetooth_serial.h slave_link.c slave_link.h
  group Shared / Protocol
    ../Shared/Protocol/: inter_mcu_protocol.c inter_mcu_protocol.h cv0850.c cv0850.h config_journal.c config_journal.h flight_parameters.c flight_parameters.h
  group App
    App/: app_scheduler.c app_scheduler.h flight_safety.c flight_safety.h flight_controller.c flight_controller.h
  group Core
    Core/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Shared / Drivers
    ../Shared/Drivers/: dma_rx.c dma_rx.h millisecond_clock.c millisecond_clock.h
  group Shared / Scheduling
    ../Shared/Scheduling/: periodic_tasks.c periodic_tasks.h task_health.c task_health.h event_notify.h
